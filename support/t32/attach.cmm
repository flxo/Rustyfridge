SYStem.CPU LPC1768
SYStem.Mode Attach
