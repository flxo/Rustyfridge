SYStem.RESetTarget
Register.Init
