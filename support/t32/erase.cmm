DO t32/reset.cmm
FLASH.ERASE all
